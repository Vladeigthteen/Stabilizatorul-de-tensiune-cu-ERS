** Profile: "SCHEMATIC1-Bucla"  [ C:\Proiect 1\P1_2024_434D_Fraticiu_Vlad (1)\P1_2024_434D_Fraticiu_Vlad\Bucla deschisa\bucla deschisa-pspicefiles\schematic1\bucla.sim ]

** Creating circuit file "Bucla.cir"
** WARNING: THIS AUTOMATICALLY GENERATED FILE MAY BE OVERWRITTEN BY SUBSEQUENT SIMULATIONS

*Libraries:
* Profile Libraries :
* Local Libraries :
.LIB "c:/proiect 1/lib_modelepspice_anexa_1/modele_a1_lib/1n4148.lib"
.LIB "c:/proiect 1/lib_modelepspice_anexa_1/modele_a1_lib/bc807-25.lib"
.LIB "c:/proiect 1/lib_modelepspice_anexa_1/modele_a1_lib/bc817-25.lib"
.LIB "c:/proiect 1/lib_modelepspice_anexa_1/modele_a1_lib/bc846b.lib"
.LIB "c:/proiect 1/lib_modelepspice_anexa_1/modele_a1_lib/bc856b.lib"
.LIB "c:/proiect 1/lib_modelepspice_anexa_1/modele_a1_lib/bzx84c2v7.lib"
.LIB "c:/proiect 1/lib_modelepspice_anexa_1/modele_a1_lib/bzx84c5v1.lib"
.LIB "c:/proiect 1/lib_modelepspice_anexa_1/modele_a1_lib/bzx84c5v6.lib"
.LIB "c:/proiect 1/lib_modelepspice_anexa_1/modele_a1_lib/bzx84c6v2.lib"
.LIB "c:/proiect 1/lib_modelepspice_anexa_1/modele_a1_lib/bzx84c6v8.lib"
.LIB "c:/proiect 1/lib_modelepspice_anexa_1/modele_a1_lib/bzx84c8v2.lib"
.LIB "c:/proiect 1/lib_modelepspice_anexa_1/modele_a1_lib/bzx84c10.lib"
.LIB "c:/proiect 1/lib_modelepspice_anexa_1/modele_a1_lib/irfr120npbf.lib"
.LIB "c:/proiect 1/lib_modelepspice_anexa_1/modele_a1_lib/mjd31cg.lib"
.LIB "c:/proiect 1/lib_modelepspice_anexa_1/modele_a1_lib/mjd32cg.lib"
.LIB "c:/proiect 1/lib_modelepspice_anexa_1/modele_a1_lib/mmbfj177lt1g.lib"
.LIB "c:/proiect 1/lib_modelepspice_anexa_1/modele_a1_lib/mmbfj309lt1g.lib"
.LIB "c:/proiect 1/lib_modelepspice_anexa_1/modele_a1_lib/opto.lib"
* From [PSPICE NETLIST] section of C:\Users\frati\AppData\Roaming\SPB_Data\cdssetup\OrCAD_PSpice\24.1.0\PSpice.ini file:
.lib "nom.lib"

*Analysis directives:
.AC DEC 100 10 100k
.OPTIONS ADVCONV
.PROBE64 V(alias(*)) I(alias(*)) W(alias(*)) D(alias(*)) NOISE(alias(*))
.INC "..\SCHEMATIC1.net"

.END
