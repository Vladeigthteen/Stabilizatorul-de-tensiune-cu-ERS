** Profile: "SCHEMATIC1-Sarcina"  [ C:\Users\frati\OneDrive\Desktop\Stabilizatorul-de-tensiune-cu-ERS-main\Stabilizatorul-de-tensiune-cu-ERS-main\P1_2024_434D_Fraticiu_Vlad\Schematic\Schematic\Stabilizator_ERS_-PSpiceFiles\SCHEMATIC1\Sarcina.sim ]

** Creating circuit file "Sarcina.cir"
** WARNING: THIS AUTOMATICALLY GENERATED FILE MAY BE OVERWRITTEN BY SUBSEQUENT SIMULATIONS

*Libraries:
* Profile Libraries :
* Local Libraries :
.LIB "c:/proiect 1/lib_modelepspice_anexa_1/modele_a1_lib/1n4148.lib"
.LIB "c:/proiect 1/lib_modelepspice_anexa_1/modele_a1_lib/bc807-25.lib"
.LIB "c:/proiect 1/lib_modelepspice_anexa_1/modele_a1_lib/bc817-25.lib"
.LIB "c:/proiect 1/lib_modelepspice_anexa_1/modele_a1_lib/bc846b.lib"
.LIB "c:/proiect 1/lib_modelepspice_anexa_1/modele_a1_lib/bc856b.lib"
.LIB "c:/proiect 1/lib_modelepspice_anexa_1/modele_a1_lib/bzx84c2v7.lib"
.LIB "c:/proiect 1/lib_modelepspice_anexa_1/modele_a1_lib/bzx84c5v1.lib"
.LIB "c:/proiect 1/lib_modelepspice_anexa_1/modele_a1_lib/bzx84c5v6.lib"
.LIB "c:/proiect 1/lib_modelepspice_anexa_1/modele_a1_lib/bzx84c6v2.lib"
.LIB "c:/proiect 1/lib_modelepspice_anexa_1/modele_a1_lib/bzx84c6v8.lib"
.LIB "c:/proiect 1/lib_modelepspice_anexa_1/modele_a1_lib/bzx84c8v2.lib"
.LIB "c:/proiect 1/lib_modelepspice_anexa_1/modele_a1_lib/bzx84c10.lib"
.LIB "c:/proiect 1/lib_modelepspice_anexa_1/modele_a1_lib/irfr120npbf.lib"
.LIB "c:/proiect 1/lib_modelepspice_anexa_1/modele_a1_lib/mjd31cg.lib"
.LIB "c:/proiect 1/lib_modelepspice_anexa_1/modele_a1_lib/mjd32cg.lib"
.LIB "c:/proiect 1/lib_modelepspice_anexa_1/modele_a1_lib/mmbfj177lt1g.lib"
.LIB "c:/proiect 1/lib_modelepspice_anexa_1/modele_a1_lib/mmbfj309lt1g.lib"
* From [PSPICE NETLIST] section of C:\Users\frati\AppData\Roaming\SPB_Data\cdssetup\OrCAD_PSpice\17.2.0\PSpice.ini file:
.lib "nomd.lib"

*Analysis directives:
.DC LIN PARAM Rload 1 53 0.1
.OPTIONS ADVCONV
.PROBE64 V(alias(*)) I(alias(*)) W(alias(*)) D(alias(*)) NOISE(alias(*))
.INC "..\SCHEMATIC1.net"

.END
